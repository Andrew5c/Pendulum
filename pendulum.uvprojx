# Keil uVision project pendulum.uvprojx, settings and files
target Pendulum (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pendulum
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\CMSIS\startup;.\FWlib\inc;.\USER;.\HARDWARE;.\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SYSTEM
    ./SYSTEM/: PID.c
  group USER
    ./USER/: main.c Hardware.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h delay.c beep.c
  group HARDWARE
    ./HARDWARE/: timer.c OLED.c word.c systick.c usart_1.c LED.c KEY.c
  group CMSIS
    G:/Dreamer手环/Dreamer_2/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group FLIB
    ./FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
